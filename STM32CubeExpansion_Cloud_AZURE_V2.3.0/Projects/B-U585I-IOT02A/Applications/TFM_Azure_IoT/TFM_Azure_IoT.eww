<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TFM_SBSFU_Boot\EWARM\TFM_SBSFU_Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFM_Loader\EWARM\Secure\TFM_Loader_S.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFM_Loader\EWARM\NonSecure\TFM_Loader_NS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFM_Appli\EWARM\Secure\TFM_Appli_G.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFM_Appli\EWARM\Secure\TFM_Appli_S.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TFM_Appli\EWARM\NonSecure\TFM_Appli_NS.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TFM_Azure_IoT</name>
            <member>
                <project>TFM_SBSFU_Boot</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_NS</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_G</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_NS</project>
                <configuration>B-U585I-IOT02A_Wifi</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>TFM_Azure_IoT - Cellular T1SC</name>
            <member>
                <project>TFM_SBSFU_Boot</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_NS</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_G</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_NS</project>
                <configuration>B-U585I-IOT02A_T1SC</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>TFM_Azure_IoT - Cellular BG96</name>
            <member>
                <project>TFM_SBSFU_Boot</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Loader_NS</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_G</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_S</project>
                <configuration>B-U585I-IOT02A</configuration>
            </member>
            <member>
                <project>TFM_Appli_NS</project>
                <configuration>B-U585I-IOT02A_BG96</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
