# IAR project TFM_Appli_G.ewp, settings and files
configuration B-U585I-IOT02A (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_g.cmd "$PROJ_DIR$" "STM32U585xx"
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: tfm_common_s.icf.i
  ILINK.IlinkExtraOptions: --semihosting; --redirect; __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
