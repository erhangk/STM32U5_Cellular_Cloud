# IAR project TFM_Appli_S.ewp, settings and files
configuration B-U585I-IOT02A (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32U585xx; USE_HAL_DRIVER; NDEBUG; TFM_PARTITION_LOG_LEVEL=3; TFM_SPM_LOG_LEVEL=3; __AS_BOUNDS__; BL2; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_PSA_API=1; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_LVL=2; MULADDC_CANNOT_USE_R7; MBEDTLS_CONFIG_FILE=<tfm_mbedcrypto_config.h>; ITS_CREATE_FLASH_LAYOUT; PS_CREATE_FLASH_LAYOUT; TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120; TFM_CRYPTO_ENGINE_BUF_SIZE=0x2c00; PS_MAX_ASSET_SIZE=2048; PS_NUM_ASSETS=10; ITS_MAX_ASSET_SIZE=2048; ITS_NUM_ASSETS=20; T_COSE_COMPILE_TIME_CONFIG; T_COSE_USE_PSA_CRYPTO; T_COSE_USE_PSA_CRYPTO_FROM_TFM; T_COSE_DISABLE_CONTENT_TYPE; BOOT_DATA_AVAILABLE; BOOT_MAX_ALIGN=16; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; INCLUDE_OPTIONAL_CLAIMS; FLOW_CONTROL; TFM_FIH_PROFILE_ON; TFM_FIH_PROFILE_HIGH; STSAFE_A110; PSA_USE_SE_ST; TFM_PARTITION_FIRMWARE_UPDATE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\ext; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\log; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\os_wrapper; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\mbedcrypto\mbedcrypto_config; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\src; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\util; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\t_cose\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\t_cose\src; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\fih\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\cmsis; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\include\; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\crypto; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\firmware_update; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\firmware_update\bootloader; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\initial_attestation; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage\flash; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage\flash_fs; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\lib\sprt; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\lib\sprt\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\platform; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage\crypto; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage\nv_counters; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\cmsis_psa; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\cmsis_psa\arch; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\include\; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\common; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext; g\interface\include; g\psa_manifest; g; g\secure_fw\partitions; g\secure_fw\spm\cmsis_psa; ..\..\..\Linker; ..\..\Secure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Middlewares\Third_Party; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\library; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls; ..\..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot\include; ..\..\..\TFM_SBSFU_Boot\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\..\Middlewares\ST\SE_STSAFEA_API\Core\Inc; ..\..\..\..\..\..\..\Middlewares\ST\SE_STSAFEA_API\Application\MbedTLS\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STSAFE_A1xx\CoreModules\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\secure_element\stm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_s.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: ..\postbuild.bat "$PROJ_DIR$"  - secure
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: tfm_common_s.icf.i
  ILINK.IlinkExtraOptions: --semihosting; --redirect; __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Secure/: VERSION
  group Application/User
    ../../Secure/Src/: aes_alt.c app_rot_test.c attest_hal.c ccm_alt.c dummy_boot_seed.c dummy_crypto_keys.c dummy_device_id.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c gcm_alt.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c md5_alt.c mpu_armv8m_drv.c nv_counters.c platform_sp.c rsa_alt.c sha1_alt.c sha256_alt.c spm_hal.c startup_stm32u5xx.c stsafea_crypto_interface.c stsafea_service_interface.c target_cfg.c tfm_app_rot.c tfm_fih.c tfm_hal_isolation.c tfm_platform_system.c tick.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/mbed-crypto
    ../../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group Middlewares/mcuboot/core
    ../../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c
  group Middlewares/stsafe_a/se_stsafea_api
    ../../../../../../../Middlewares/ST/SE_STSAFEA_API/Core/Src/: se_stsafea_api.c
  group Middlewares/stsafe_a/stsafe_axx0
    ../../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
  group Middlewares/trustedfirmware/core
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/initial_attestation/: attest_asymmetric_key.c attest_core.c attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c tfm_attest_secure_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/lib/sprt/: crt_memcmp.c crt_memcpy.c crt_memmove.c crt_memset.c service_api.c sprt_partition_metadata_indicator.c tfm_sp_log_raw.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c tfm_crypto_secure_api.c tfm_mbedcrypto_alt.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm/cmsis_psa/: exception_info.c main.c spm_ipc.c tfm_core_svcalls_ipc.c tfm_nspm_ipc.c tfm_pools.c tfm_psa_api_veneers.c tfm_thread.c tfm_wait.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/fih/src/: fih.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/src/: flash_map.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: flash_map_extended.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    g/auto_generated/: intermedia_tfm_app_rot.c intermedia_tfm_crypto.c intermedia_tfm_firmware_update.c intermedia_tfm_initial_attestation.c intermedia_tfm_internal_trusted_storage.c intermedia_tfm_platform.c intermedia_tfm_protected_storage.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash_nand.c its_flash_nor.c its_flash_ram.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/: ps_encrypted_object.c ps_object_system.c ps_object_table.c ps_utils.c tfm_protected_storage.c tfm_ps_req_mngr.c tfm_ps_secure_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/psa/: psa_client.c psa_lifecycle.c psa_service.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm/ffm/: psa_client_service_apis.c spm_log.c spm_psa_client_call.c tfm_boot_data.c tfm_core_utils.c utilities.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/util/: qcbor_util.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/secure_element/stm/: se_psa.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/t_cose/src/: t_cose_parameters.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/firmware_update/: tfm_fwu.c tfm_fwu_req_mngr.c tfm_fwu_secure_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: tfm_hal_isolation_mpu_v8m.c tfm_hal_its.c tfm_hal_ps.c tfm_hal_spm_logdev_peripheral.c tfm_platform.c uart_stdout.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/firmware_update/bootloader/mcuboot/: tfm_mcuboot_fwu.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/platform/: tfm_platform_secure_api.c
  group Middlewares/trustedfirmware/test
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
