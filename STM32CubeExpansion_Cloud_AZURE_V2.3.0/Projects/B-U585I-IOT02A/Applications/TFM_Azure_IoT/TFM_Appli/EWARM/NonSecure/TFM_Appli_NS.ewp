# IAR project TFM_Appli_NS.ewp, settings and files
configuration B-U585I-IOT02A_Wifi (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_WIFI=1; APPLICATION_CONFIG_FILE="app_azure_iot_config.h"; USE_DYNAMIC_MEMORY_ALLOCATION; RTOS2_BYTE_POOL_STACK_SIZE=(16*1024); RTOS2_BYTE_POOL_HEAP_SIZE=(4*1024); NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; TFM_1_3=1; TFM_1_0=0; STM32U585xx; USE_HAL_DRIVER; BL2; SST_ENCRYPTION; TFM_PSA_API; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_PARTITION_FIRMWARE_UPDATE; TFM_LVL=2; DEFAULT_UART_BAUDRATE=115200; DOMAIN_NS=1; TX_SINGLE_MODE_NON_SECURE=1; PSA_USE_SE_ST; NX_SECURE_INCLUDE_USER_DEFINE_FILE; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_SILENCE; GET_CONFIG_FROM_SECURE_STORAGE; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base
  ICCARM.CCIncludePath2: ..\..\NonSecure\Core\Inc; ..\..\NonSecure\AZURE_RTOS\App; ..\..\NonSecure\NetXDuo\App; ..\..\NonSecure\NetXDuo\Target; ..\..\NonSecure\psa_crypto_ciphersuites; ..\..\Secure_nsclib; ..\Secure\g\interface\include; ..\..\..\Linker; ..\..\..\..\..\..\..\Drivers/CMSIS/Include; ..\..\..\..\..\..\..\Drivers/BSP/B-U585I-IOT02A; ..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/STM32U5xx/Include; ..\..\..\..\..\..\..\Drivers/STM32U5xx_HAL_Driver/Inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/mbedtls; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/psa; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include/log; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/cmsis; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/driver; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/framework; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/suites/crypto; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/secure_element/stm; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dhcp; ..\..\..\..\..\..\..\Middlewares/ST/threadx/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/ports/cortex_m33/iar/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dns; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/mqtt; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/sntp; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/cloud; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/web; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/ports; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/ports/cortex_m4/gnu/inc; ..\..\..\..\..\..\..\Middlewares/ST/threadx/ports/cortex_m33/gnu/inc; ..\..\NonSecure\Wifi; ..\..\..\..\..\..\..\Drivers\BSP\Components\mx_wifi; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\wifi\mxchip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_NON_SECURE; USE_DYNAMIC_MEMORY_ALLOCATION
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: "$PROJ_DIR$"\prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: md "$PROJ_DIR$"\B-U585I-IOT02A\Exe 2> NUL & xcopy /Y "$TARGET_DIR$"\Project.bin "$PROJ_DIR$"\B-U585I-IOT02A\Exe\ & xcopy /Y "$TARGET_DIR$"\B-U585I-IOT02A.out "$PROJ_DIR$"\B-U585I-IOT02A\Exe\ & "$PROJ_DIR$"\..\postbuild.bat "$PROJ_DIR$" - nonsecure
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: stm32u585xx_flash_ns.icf.i
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker
  ILINK.IlinkAdditionalLibs: ..\Secure\B-U585I-IOT02A\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration B-U585I-IOT02A_BG96 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_CELLULAR=1; APPLICATION_CONFIG_FILE="app_azure_iot_config.h"; USE_DYNAMIC_MEMORY_ALLOCATION; RTOS2_BYTE_POOL_STACK_SIZE=(16*1024); RTOS2_BYTE_POOL_HEAP_SIZE=(4*1024); NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; TFM_1_3=1; TFM_1_0=0; STM32U585xx; USE_HAL_DRIVER; BL2; SST_ENCRYPTION; TFM_PSA_API; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_PARTITION_FIRMWARE_UPDATE; TFM_LVL=2; DEFAULT_UART_BAUDRATE=115200; DOMAIN_NS=1; TX_SINGLE_MODE_NON_SECURE=1; PSA_USE_SE_ST; NX_SECURE_INCLUDE_USER_DEFINE_FILE; TFM_SPM_LOG_LEVEL=TFM_SPM_LOG_LEVEL_SILENCE; GET_CONFIG_FROM_SECURE_STORAGE; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base
  ICCARM.CCIncludePath2: ..\..\NonSecure\Core\Inc; ..\..\NonSecure\AZURE_RTOS\App; ..\..\NonSecure\NetXDuo\App; ..\..\NonSecure\NetXDuo\Target; ..\..\NonSecure\psa_crypto_ciphersuites; ..\..\Secure_nsclib; ..\Secure\g\interface\include; ..\..\..\Linker; ..\..\..\..\..\..\..\Drivers/CMSIS/Include; ..\..\..\..\..\..\..\Drivers/BSP/B-U585I-IOT02A; ..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/STM32U5xx/Include; ..\..\..\..\..\..\..\Drivers/STM32U5xx_HAL_Driver/Inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/mbedtls; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/psa; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include/log; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/cmsis; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/driver; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/framework; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/suites/crypto; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/secure_element/stm; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dhcp; ..\..\..\..\..\..\..\Middlewares/ST/threadx/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/ports/cortex_m33/iar/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dns; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/mqtt; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/sntp; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/cloud; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/web; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/ports; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/ports/cortex_m4/iar/inc; ..\..\..\..\..\..\..\Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ..\..\NonSecure\Cellular; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Template; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\..\Drivers\BSP\Components\cellular\BG96\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Misc\Cmd\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\cellular; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Misc\Cmd\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\cellular
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: cmd /C "md B-U585I-IOT02A\Exe 2> NUL & xcopy /Y $TARGET_DIR$\Project.bin B-U585I-IOT02A\Exe\ & xcopy /Y $TARGET_DIR$\B-U585I-IOT02A.out B-U585I-IOT02A\Exe\ & ..\postbuild.bat $PROJ_DIR$ - nonsecure"
configuration B-U585I-IOT02A_T1SC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ..\..\NonSecure\Core\Inc; ..\..\NonSecure\AZURE_RTOS\App; ..\..\NonSecure\NetXDuo\App; ..\..\NonSecure\NetXDuo\Target; ..\..\NonSecure\psa_crypto_ciphersuites; ..\..\Secure_nsclib; ..\Secure\g\interface\include; ..\..\..\Linker; ..\..\..\..\..\..\..\Drivers/CMSIS/Include; ..\..\..\..\..\..\..\Drivers/BSP/B-U585I-IOT02A; ..\..\..\..\..\..\..\Drivers/CMSIS/Device/ST/STM32U5xx/Include; ..\..\..\..\..\..\..\Drivers/STM32U5xx_HAL_Driver/Inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/mbedtls; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include/psa; ..\..\..\..\..\..\..\Middlewares/Third_Party/mbed-crypto/include; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/interface/include/log; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/cmsis; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/driver; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/framework; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/test/suites/crypto; ..\..\..\..\..\..\..\Middlewares/Third_Party/trustedfirmware/platform/ext/secure_element/stm; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dhcp; ..\..\..\..\..\..\..\Middlewares/ST/threadx/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/common/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/ports/cortex_m33/iar/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/dns; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/mqtt; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/sntp; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/cloud; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/inc/configs/RTOS_BASE; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/include; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/addons/web; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/nx_secure/ports; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/inc; ..\..\..\..\..\..\..\Middlewares/ST/netxduo/crypto_libraries/ports/cortex_m4/iar/inc; ..\..\..\..\..\..\..\Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ..\..\NonSecure\Cellular; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Template; ..\..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\..\Drivers\BSP\Components\cellular\TYPE1SC\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Misc\Cmd\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\cellular; ..\..\..\..\..\..\..\Middlewares\ST\STM32_Cellular\Misc\Cmd\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\cellular
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: as above
  group Application
    ../../NonSecure/: VERSION
  group Application/AZURE_RTOS/App
    ../../NonSecure/AZURE_RTOS/App/: app_azure_rtos.c app_azure_rtos.h app_azure_rtos_config.h app_threadx.c app_threadx.h
  group Application/Cellular
    ../../NonSecure/Cellular/: plf_cellular_config.h plf_config.h plf_features.h plf_hw_config.h plf_ipc_config.h plf_power_config.h plf_rtosal_config.h plf_sw_config.h plf_thread_config.h
  group Application/NetXDuo/App
    ../../NonSecure/NetXDuo/App/: app_azure_iot.c app_azure_iot.h app_azure_iot_adu_agent_ns_driver.c app_azure_iot_adu_agent_s_driver.c app_azure_iot_config.h app_azure_iot_embedded_sdk_adu.c app_azure_iot_embedded_sdk_connect.c app_azure_iot_version.h app_netxduo.c app_netxduo.h ctrl_component.c ctrl_component.h device_identity.c device_identity.h device_info_component.c device_info_component.h dm_http_status_code.h nx_azure_iot_cert.c nx_azure_iot_cert.h nx_azure_iot_ciphersuites.c nx_azure_iot_ciphersuites.h nx_secure_user.h nx_user.h std_component.c std_component.h
  group Application/PSA_Crypto_Ciphersuites
    ../../NonSecure/psa_crypto_ciphersuites/: nx_crypto_aes_psa.c nx_crypto_aes_psa.h nx_crypto_ecdsa_psa_crypto.c nx_crypto_ecdsa_psa_crypto.h nx_crypto_psa_crypto_ciphersuites.c nx_crypto_rsa_psa.c nx_crypto_rsa_psa.h nx_crypto_sha_psa.c nx_crypto_sha_psa.h
  group Application/User
    ../../NonSecure/Core/Src/: app_config.c common.c main.c mpu_armv8m_drv.c startup_stm32u5xx.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c tfm_ns_lock.c tx_initialize_low_level.s
    ../../NonSecure/Core/Inc/: app_config.h common.h main.h mpu_armv8m_drv.h ns_data.h stm32u5xx_hal_conf.h tx_user.h
  group Application/Wifi
    ../../NonSecure/Wifi/: mx_wifi_conf.h
  group Doc
    ../../../: README.md
  group Drivers/BSP/B-U585I-IOT02A
    ../../../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a.c b_u585i_iot02a_bus.c b_u585i_iot02a_env_sensors.c b_u585i_iot02a_motion_sensors.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
  group Drivers/BSP/Components/cellular/BG96
    ../../../../../../../Drivers/BSP/Components/cellular/BG96/Src/: at_custom_modem_api.c at_custom_modem_sid.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c at_custom_sysctrl.c
    ../../../../../../../Drivers/BSP/Components/cellular/BG96/Inc/: plf_modem_config.h
  group Drivers/BSP/Components/cellular/TYPE1SC
    ../../../../../../../Drivers/BSP/Components/cellular/TYPE1SC/Src/: at_custom_modem_api.c at_custom_modem_sid.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c at_custom_sysctrl.c
    ../../../../../../../Drivers/BSP/Components/cellular/TYPE1SC/Inc/: plf_modem_config.h
  group Drivers/BSP/Components/mx_wifi
    ../../../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c mx_wifi.h mx_wifi_bare_os.h mx_wifi_cmsis_os.h mx_wifi_conf_template.h
  group Drivers/BSP/Components/mx_wifi/Core
    ../../../../../../../Drivers/BSP/Components/mx_wifi/core/: checksumutils.c checksumutils.h mx_rtos_abs.c mx_rtos_abs.h mx_wifi_hci.c mx_wifi_hci.h mx_wifi_ipc.c mx_wifi_ipc.h mx_wifi_slip.c mx_wifi_slip.h
  group Drivers/BSP/Components/mx_wifi/IO_pattern
    ../../../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
  group Drivers/BSP/Components/STDIO
    ../../NonSecure/Core/Src/: stdin_usart.c stdout_usart.c
  group Drivers/CMSIS
    ../../NonSecure/Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c
  group Middlewares/cellular/Core/AT_Core
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_socket.c at_parser.c at_signalling_analyze.c at_signalling_build.c at_sysctrl.c at_util.c
  group Middlewares/cellular/Core/Cellular_Service
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_datacache.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_socket.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/cellular/Core/Data_Cache
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/cellular/Core/Error
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/cellular/Core/Ipc
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/cellular/Core/Rtosal
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/cellular/Core/Runtime_Library
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/cellular/Core/Trace
    ../../../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/cellular/Interface/Com
    ../../../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c com_utils.c
  group Middlewares/cellular/Interface/Control
    ../../../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/cellular/Misc/Cmd
    ../../../../../../../Middlewares/ST/STM32_Cellular/Misc/Cmd/Src/: cmd.c
  group Middlewares/cmsis_rtos_threadx
    ../../../../../../../Middlewares/ST/cmsis_rtos_threadx/: cmsis_os2.c
  group Middlewares/netxduo/addons/azure_iot
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/: nx_azure_iot.c nx_azure_iot.h nx_azure_iot_adu_agent.c nx_azure_iot_adu_agent.h nx_azure_iot_adu_root_key.c nx_azure_iot_hub_client.c nx_azure_iot_hub_client.h nx_azure_iot_hub_client_properties.c nx_azure_iot_hub_client_properties.h nx_azure_iot_json_reader.c nx_azure_iot_json_reader.h nx_azure_iot_json_writer.c nx_azure_iot_json_writer.h nx_azure_iot_provisioning_client.c nx_azure_iot_provisioning_client.h
  group Middlewares/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/core
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/core/: az_context.c az_hex_private.h az_http_header_validation_private.h az_http_pipeline.c az_http_policy.c az_http_policy_logging.c az_http_policy_logging_private.h az_http_policy_retry.c az_http_private.h az_http_request.c az_http_response.c az_json_private.h az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c az_span_private.h
  group Middlewares/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/iot
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_commands.c az_iot_hub_client_methods.c az_iot_hub_client_properties.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/: nx_azure_iot_security_module.c nx_azure_iot_security_module.h
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/deps/flatcc/src/runtime/: builder.c emitter.c refmap.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/: collector_collection.c collectors_info.c components_factory.c components_manager.c core.c logger.c object_pool_static.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/collectors/: collector_heartbeat.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/model
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/model/: collector.c security_message.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/: heartbeat.c network_activity.c protocol_serialize_enum.h serializer.c serializer_private.c serializer_private.h system_information.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/serializer/extensions/: custom_builder_allocator.c page_allocator.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/utils
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/: event_loop_be.c iconv.c notifier.c string_utils.c uuid.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/collection
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/iot-security-module-core/src/utils/collection/: bit_vector.c hashtable.c list.c stack.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/src/collectors
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/src/collectors/: collector_network_activity.c collector_system_information.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/src/model/object
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/src/model/objects/: object_network_activity_ext.c
  group Middlewares/netxduo/addons/azure_iot/azure_iot_security_module/src/utils
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/azure_iot_security_module/src/utils/: ievent_loop.c irand.c itime.c os_utils.c
  group Middlewares/netxduo/addons/azure_iot/sample/sample
    ../../../../../../../Middlewares/ST/netxduo/addons/azure_iot/samples/cert/: nx_azure_iot_cert.h
  group Middlewares/netxduo/addons/cloud
    ../../../../../../../Middlewares/ST/netxduo/addons/cloud/: nx_cloud.c nx_cloud.h
  group Middlewares/netxduo/addons/dhcp
    ../../../../../../../Middlewares/ST/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h
  group Middlewares/netxduo/addons/dns
    ../../../../../../../Middlewares/ST/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group Middlewares/netxduo/addons/mqtt
    ../../../../../../../Middlewares/ST/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
  group Middlewares/netxduo/addons/sntp
    ../../../../../../../Middlewares/ST/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group Middlewares/netxduo/addons/web
    ../../../../../../../Middlewares/ST/netxduo/addons/web/: nx_web_http_client.c nx_web_http_client.h nx_web_http_common.h
  group Middlewares/netxduo/core
    ../../../../../../../Middlewares/ST/netxduo/common/src/: nx_arp_announce_send.c nx_arp_dynamic_entries_invalidate.c nx_arp_dynamic_entry_delete.c nx_arp_dynamic_entry_set.c nx_arp_enable.c nx_arp_entry_allocate.c nx_arp_entry_delete.c nx_arp_gratuitous_send.c nx_arp_hardware_address_find.c nx_arp_info_get.c nx_arp_initialize.c nx_arp_interface_entries_delete.c nx_arp_ip_address_find.c nx_arp_packet_deferred_receive.c nx_arp_packet_receive.c nx_arp_packet_send.c nx_arp_periodic_update.c nx_arp_probe_send.c nx_arp_queue_process.c nx_arp_queue_send.c nx_arp_static_entries_delete.c nx_arp_static_entry_create.c nx_arp_static_entry_delete.c nx_arp_static_entry_delete_internal.c nx_icmp_cleanup.c nx_icmp_enable.c nx_icmp_info_get.c nx_icmp_interface_ping.c nx_icmp_interface_ping6.c nx_icmp_packet_process.c nx_icmp_packet_receive.c nx_icmp_ping.c nx_icmp_ping6.c nx_icmp_queue_process.c nx_icmpv4_packet_process.c nx_icmpv4_process_echo_reply.c nx_icmpv4_process_echo_request.c nx_icmpv4_send_error_message.c nx_icmpv6_DAD_clear_NDCache_entry.c nx_icmpv6_DAD_failure.c nx_icmpv6_dest_table_add.c nx_icmpv6_dest_table_find.c nx_icmpv6_destination_table_periodic_update.c nx_icmpv6_packet_process.c nx_icmpv6_perform_DAD.c nx_icmpv6_process_echo_reply.c nx_icmpv6_process_echo_request.c nx_icmpv6_process_na.c nx_icmpv6_process_ns.c nx_icmpv6_process_packet_too_big.c nx_icmpv6_process_ra.c nx_icmpv6_process_redirect.c nx_icmpv6_send_error_message.c nx_icmpv6_send_ns.c nx_icmpv6_send_queued_packets.c nx_icmpv6_send_rs.c nx_icmpv6_validate_neighbor_message.c nx_icmpv6_validate_options.c nx_icmpv6_validate_ra.c nx_igmp_enable.c nx_igmp_info_get.c nx_igmp_interface_report_send.c nx_igmp_loopback_disable.c nx_igmp_loopback_enable.c nx_igmp_multicast_check.c nx_igmp_multicast_interface_join.c nx_igmp_multicast_interface_join_internal.c nx_igmp_multicast_interface_leave.c nx_igmp_multicast_interface_leave_internal.c nx_igmp_multicast_join.c nx_igmp_multicast_leave.c nx_igmp_packet_process.c nx_igmp_packet_receive.c nx_igmp_periodic_processing.c nx_igmp_queue_process.c nx_invalidate_destination_entry.c nx_ip_address_change_notify.c nx_ip_address_get.c nx_ip_address_set.c nx_ip_auxiliary_packet_pool_set.c nx_ip_checksum_compute.c nx_ip_create.c nx_ip_deferred_link_status_process.c nx_ip_delete.c nx_ip_delete_queue_clear.c nx_ip_dispatch_process.c nx_ip_driver_deferred_enable.c nx_ip_driver_deferred_processing.c nx_ip_driver_deferred_receive.c nx_ip_driver_direct_command.c nx_ip_driver_interface_direct_command.c nx_ip_driver_link_status_event.c nx_ip_driver_packet_send.c nx_ip_fast_periodic_timer_entry.c nx_ip_forward_packet_process.c nx_ip_forwarding_disable.c nx_ip_forwarding_enable.c nx_ip_fragment_assembly.c nx_ip_fragment_disable.c nx_ip_fragment_enable.c nx_ip_fragment_forward_packet.c nx_ip_fragment_packet.c nx_ip_fragment_timeout_check.c nx_ip_gateway_address_clear.c nx_ip_gateway_address_get.c nx_ip_gateway_address_set.c nx_ip_header_add.c nx_ip_info_get.c nx_ip_initialize.c nx_ip_interface_address_get.c nx_ip_interface_address_mapping_configure.c nx_ip_interface_address_set.c nx_ip_interface_attach.c nx_ip_interface_capability_get.c nx_ip_interface_capability_set.c nx_ip_interface_detach.c nx_ip_interface_info_get.c nx_ip_interface_mtu_set.c nx_ip_interface_physical_address_get.c nx_ip_interface_physical_address_set.c nx_ip_interface_status_check.c nx_ip_link_status_change_notify_set.c nx_ip_max_payload_size_find.c nx_ip_packet_checksum_compute.c nx_ip_packet_deferred_receive.c nx_ip_packet_receive.c nx_ip_packet_send.c nx_ip_periodic_timer_entry.c nx_ip_raw_packet_cleanup.c nx_ip_raw_packet_disable.c nx_ip_raw_packet_enable.c nx_ip_raw_packet_filter_set.c nx_ip_raw_packet_processing.c nx_ip_raw_packet_receive.c nx_ip_raw_packet_send.c nx_ip_raw_packet_source_send.c nx_ip_raw_receive_queue_max_set.c nx_ip_route_find.c nx_ip_static_route_add.c nx_ip_static_route_delete.c nx_ip_status_check.c nx_ip_thread_entry.c nx_ipv4_multicast_interface_join.c nx_ipv4_multicast_interface_leave.c nx_ipv4_option_process.c nx_ipv4_packet_receive.c nx_ipv6_fragment_process.c nx_ipv6_header_add.c nx_ipv6_multicast_join.c nx_ipv6_multicast_leave.c nx_ipv6_option_error.c nx_ipv6_packet_copy.c nx_ipv6_packet_receive.c nx_ipv6_packet_send.c nx_ipv6_prefix_list_add_entry.c nx_ipv6_prefix_list_delete.c nx_ipv6_prefix_list_delete_entry.c nx_ipv6_process_fragment_option.c nx_ipv6_process_hop_by_hop_option.c nx_ipv6_process_routing_option.c nx_ipv6_util.c nx_md5.c nx_nd_cache_add.c nx_nd_cache_add_entry.c nx_nd_cache_delete_internal.c nx_nd_cache_fast_periodic_update.c nx_nd_cache_find_entry.c nx_nd_cache_find_entry_by_mac_addr.c nx_nd_cache_interface_entries_delete.c nx_nd_cache_slow_periodic_update.c nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_ram_network_driver.c nx_rarp_disable.c nx_rarp_enable.c nx_rarp_info_get.c nx_rarp_packet_deferred_receive.c nx_rarp_packet_receive.c nx_rarp_packet_send.c nx_rarp_periodic_update.c nx_rarp_queue_process.c nx_system_initialize.c nx_tcp_cleanup_deferred.c nx_tcp_client_bind_cleanup.c nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_port_get.c nx_tcp_client_socket_unbind.c nx_tcp_connect_cleanup.c nx_tcp_deferred_cleanup_check.c nx_tcp_disconnect_cleanup.c nx_tcp_enable.c nx_tcp_fast_periodic_processing.c nx_tcp_free_port_find.c nx_tcp_info_get.c nx_tcp_initialize.c nx_tcp_mss_option_get.c nx_tcp_no_connection_reset.c nx_tcp_packet_process.c nx_tcp_packet_receive.c nx_tcp_packet_send_ack.c nx_tcp_packet_send_control.c nx_tcp_packet_send_fin.c nx_tcp_packet_send_probe.c nx_tcp_packet_send_rst.c nx_tcp_packet_send_syn.c nx_tcp_periodic_processing.c nx_tcp_queue_process.c nx_tcp_receive_cleanup.c nx_tcp_server_socket_accept.c nx_tcp_server_socket_driver_listen.c nx_tcp_server_socket_listen.c nx_tcp_server_socket_relisten.c nx_tcp_server_socket_unaccept.c nx_tcp_server_socket_unlisten.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_bytes_available.c nx_tcp_socket_connection_reset.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_disconnect_complete_notify.c nx_tcp_socket_driver_establish.c nx_tcp_socket_driver_packet_receive.c nx_tcp_socket_establish_notify.c nx_tcp_socket_info_get.c nx_tcp_socket_mss_get.c nx_tcp_socket_mss_peer_get.c nx_tcp_socket_mss_set.c nx_tcp_socket_packet_process.c nx_tcp_socket_peer_info_get.c nx_tcp_socket_queue_depth_notify_set.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_receive_queue_flush.c nx_tcp_socket_receive_queue_max_set.c nx_tcp_socket_retransmit.c nx_tcp_socket_send.c nx_tcp_socket_send_internal.c nx_tcp_socket_state_ack_check.c nx_tcp_socket_state_closing.c nx_tcp_socket_state_data_check.c nx_tcp_socket_state_established.c nx_tcp_socket_state_fin_wait1.c nx_tcp_socket_state_fin_wait2.c nx_tcp_socket_state_last_ack.c nx_tcp_socket_state_syn_received.c nx_tcp_socket_state_syn_sent.c nx_tcp_socket_state_transmit_check.c nx_tcp_socket_state_wait.c nx_tcp_socket_thread_resume.c nx_tcp_socket_thread_suspend.c nx_tcp_socket_timed_wait_callback.c nx_tcp_socket_transmit_configure.c nx_tcp_socket_transmit_queue_flush.c nx_tcp_socket_window_update_notify_set.c nx_tcp_transmit_cleanup.c nx_tcp_window_scaling_option_get.c nx_trace_event_insert.c nx_trace_event_update.c nx_trace_object_register.c nx_trace_object_unregister.c nx_udp_bind_cleanup.c nx_udp_enable.c nx_udp_free_port_find.c nx_udp_info_get.c nx_udp_packet_info_extract.c nx_udp_packet_receive.c nx_udp_receive_cleanup.c nx_udp_socket_bind.c nx_udp_socket_bytes_available.c nx_udp_socket_checksum_disable.c nx_udp_socket_checksum_enable.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_driver_packet_receive.c nx_udp_socket_info_get.c nx_udp_socket_port_get.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_source_send.c nx_udp_socket_unbind.c nx_udp_source_extract.c nx_utility.c nxd_icmp_enable.c nxd_icmp_ping.c nxd_icmp_source_ping.c nxd_icmpv6_ra_flag_callback_set.c nxd_ip_raw_packet_send.c nxd_ip_raw_packet_source_send.c nxd_ipv6_address_change_notify.c nxd_ipv6_address_delete.c nxd_ipv6_address_get.c nxd_ipv6_address_set.c nxd_ipv6_default_router_add.c nxd_ipv6_default_router_add_internal.c nxd_ipv6_default_router_delete.c nxd_ipv6_default_router_entry_get.c nxd_ipv6_default_router_get.c nxd_ipv6_default_router_number_of_entries_get.c nxd_ipv6_default_router_table_init.c nxd_ipv6_destination_table_find_next_hop.c nxd_ipv6_disable.c nxd_ipv6_enable.c nxd_ipv6_find_default_router_from_address.c nxd_ipv6_find_max_prefix_length.c nxd_ipv6_interface_find.c nxd_ipv6_multicast_interface_join.c nxd_ipv6_multicast_interface_leave.c nxd_ipv6_prefix_router_timer_tick.c nxd_ipv6_raw_packet_send_internal.c nxd_ipv6_router_lookup.c nxd_ipv6_router_solicitation_check.c nxd_ipv6_search_onlink.c nxd_ipv6_stateless_address_autoconfig_disable.c nxd_ipv6_stateless_address_autoconfig_enable.c nxd_nd_cache_entry_delete.c nxd_nd_cache_entry_set.c nxd_nd_cache_hardware_address_find.c nxd_nd_cache_invalidate.c nxd_nd_cache_ip_address_find.c nxd_tcp_client_socket_connect.c nxd_tcp_socket_peer_info_get.c nxd_udp_packet_info_extract.c nxd_udp_socket_send.c nxd_udp_socket_source_send.c nxd_udp_source_extract.c nxde_icmp_enable.c nxde_icmp_ping.c nxde_icmp_source_ping.c nxde_icmpv6_ra_flag_callback_set.c nxde_ip_raw_packet_send.c nxde_ip_raw_packet_source_send.c nxde_ipv6_address_change_notify.c nxde_ipv6_address_delete.c nxde_ipv6_address_get.c nxde_ipv6_address_set.c nxde_ipv6_default_router_add.c nxde_ipv6_default_router_delete.c nxde_ipv6_default_router_entry_get.c nxde_ipv6_default_router_get.c nxde_ipv6_default_router_number_of_entries_get.c nxde_ipv6_disable.c nxde_ipv6_enable.c nxde_ipv6_multicast_interface_join.c nxde_ipv6_multicast_interface_leave.c nxde_ipv6_stateless_address_autoconfig_disable.c nxde_ipv6_stateless_address_autoconfig_enable.c nxde_nd_cache_entry_delete.c nxde_nd_cache_entry_set.c nxde_nd_cache_hardware_address_find.c nxde_nd_cache_invalidate.c nxde_nd_cache_ip_address_find.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_packet_info_extract.c nxde_udp_socket_send.c nxde_udp_socket_source_send.c nxde_udp_source_extract.c nxe_arp_dynamic_entries_invalidate.c nxe_arp_dynamic_entry_set.c nxe_arp_enable.c nxe_arp_entry_delete.c nxe_arp_gratuitous_send.c nxe_arp_hardware_address_find.c nxe_arp_info_get.c nxe_arp_ip_address_find.c nxe_arp_static_entries_delete.c nxe_arp_static_entry_create.c nxe_arp_static_entry_delete.c nxe_icmp_enable.c nxe_icmp_info_get.c nxe_icmp_ping.c nxe_igmp_enable.c nxe_igmp_info_get.c nxe_igmp_loopback_disable.c nxe_igmp_loopback_enable.c nxe_igmp_multicast_interface_join.c nxe_igmp_multicast_interface_leave.c nxe_igmp_multicast_join.c nxe_igmp_multicast_leave.c nxe_ip_address_change_notify.c nxe_ip_address_get.c nxe_ip_address_set.c nxe_ip_auxiliary_packet_pool_set.c nxe_ip_create.c nxe_ip_delete.c nxe_ip_driver_direct_command.c nxe_ip_driver_interface_direct_command.c nxe_ip_forwarding_disable.c nxe_ip_forwarding_enable.c nxe_ip_fragment_disable.c nxe_ip_fragment_enable.c nxe_ip_gateway_address_clear.c nxe_ip_gateway_address_get.c nxe_ip_gateway_address_set.c nxe_ip_info_get.c nxe_ip_interface_address_get.c nxe_ip_interface_address_mapping_configure.c nxe_ip_interface_address_set.c nxe_ip_interface_attach.c nxe_ip_interface_capability_get.c nxe_ip_interface_capability_set.c nxe_ip_interface_detach.c nxe_ip_interface_info_get.c nxe_ip_interface_mtu_set.c nxe_ip_interface_physical_address_get.c nxe_ip_interface_physical_address_set.c nxe_ip_interface_status_check.c nxe_ip_link_status_change_notify_set.c nxe_ip_max_payload_size_find.c nxe_ip_raw_packet_disable.c nxe_ip_raw_packet_enable.c nxe_ip_raw_packet_filter_set.c nxe_ip_raw_packet_receive.c nxe_ip_raw_packet_send.c nxe_ip_raw_packet_source_send.c nxe_ip_raw_receive_queue_max_set.c nxe_ip_static_route_add.c nxe_ip_static_route_delete.c nxe_ip_status_check.c nxe_ipv4_multicast_interface_join.c nxe_ipv4_multicast_interface_leave.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_rarp_disable.c nxe_rarp_enable.c nxe_rarp_info_get.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_port_get.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_free_port_find.c nxe_tcp_info_get.c nxe_tcp_server_socket_accept.c nxe_tcp_server_socket_listen.c nxe_tcp_server_socket_relisten.c nxe_tcp_server_socket_unaccept.c nxe_tcp_server_socket_unlisten.c nxe_tcp_socket_bytes_available.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_disconnect_complete_notify.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_info_get.c nxe_tcp_socket_mss_get.c nxe_tcp_socket_mss_peer_get.c nxe_tcp_socket_mss_set.c nxe_tcp_socket_peer_info_get.c nxe_tcp_socket_queue_depth_notify_set.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_receive_queue_max_set.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_tcp_socket_timed_wait_callback.c nxe_tcp_socket_transmit_configure.c nxe_tcp_socket_window_update_notify_set.c nxe_udp_enable.c nxe_udp_free_port_find.c nxe_udp_info_get.c nxe_udp_packet_info_extract.c nxe_udp_socket_bind.c nxe_udp_socket_bytes_available.c nxe_udp_socket_checksum_disable.c nxe_udp_socket_checksum_enable.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_info_get.c nxe_udp_socket_port_get.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_source_send.c nxe_udp_socket_unbind.c nxe_udp_source_extract.c
  group Middlewares/netxduo/crypto
    ../../../../../../../Middlewares/ST/netxduo/crypto_libraries/src/: nx_crypto_3des.c nx_crypto_aes.c nx_crypto_cbc.c nx_crypto_ccm.c nx_crypto_ctr.c nx_crypto_des.c nx_crypto_dh.c nx_crypto_ec.c nx_crypto_ec_secp192r1_fixed_points.c nx_crypto_ec_secp224r1_fixed_points.c nx_crypto_ec_secp256r1_fixed_points.c nx_crypto_ec_secp384r1_fixed_points.c nx_crypto_ec_secp521r1_fixed_points.c nx_crypto_ecdh.c nx_crypto_ecdsa.c nx_crypto_ecjpake.c nx_crypto_gcm.c nx_crypto_generic_ciphersuites.c nx_crypto_hkdf.c nx_crypto_hmac.c nx_crypto_hmac_md5.c nx_crypto_hmac_sha1.c nx_crypto_hmac_sha2.c nx_crypto_hmac_sha5.c nx_crypto_huge_number.c nx_crypto_huge_number_extended.c nx_crypto_initialize.c nx_crypto_md5.c nx_crypto_method_self_test.c nx_crypto_method_self_test_3des.c nx_crypto_method_self_test_aes.c nx_crypto_method_self_test_des.c nx_crypto_method_self_test_drbg.c nx_crypto_method_self_test_ecdh.c nx_crypto_method_self_test_ecdsa.c nx_crypto_method_self_test_hmac_md5.c nx_crypto_method_self_test_hmac_sha.c nx_crypto_method_self_test_md5.c nx_crypto_method_self_test_pkcs1.c nx_crypto_method_self_test_prf.c nx_crypto_method_self_test_rsa.c nx_crypto_method_self_test_sha.c nx_crypto_methods.c nx_crypto_null_cipher.c nx_crypto_phash.c nx_crypto_pkcs1_v1.5.c nx_crypto_rsa.c nx_crypto_sha1.c nx_crypto_sha2.c nx_crypto_sha5.c nx_crypto_tls_prf_1.c nx_crypto_tls_prf_sha256.c nx_crypto_tls_prf_sha384.c nx_crypto_tls_prf_sha512.c nx_crypto_xcbc_mac.c
  group Middlewares/netxduo/drivers/cellular
    ../../../../../../../Middlewares/ST/netxduo/common/drivers/cellular/: nx_driver_stm32_cellular.c
  group Middlewares/netxduo/drivers/wifi
    ../../../../../../../Middlewares/ST/netxduo/common/drivers/wifi/mxchip/: mx_wifi_azure_rtos.c nx_driver_emw3080.c nx_driver_emw3080.h nx_driver_framework.h
  group Middlewares/netxduo/nx_secure
    ../../../../../../../Middlewares/ST/netxduo/nx_secure/src/: nx_secure_dtls_allocate_handshake_packet.c nx_secure_dtls_client_handshake.c nx_secure_dtls_client_protocol_version_override.c nx_secure_dtls_client_session_start.c nx_secure_dtls_ecc_initialize.c nx_secure_dtls_hash_record.c nx_secure_dtls_initialize.c nx_secure_dtls_packet_allocate.c nx_secure_dtls_process_clienthello.c nx_secure_dtls_process_handshake_header.c nx_secure_dtls_process_header.c nx_secure_dtls_process_helloverifyrequest.c nx_secure_dtls_process_record.c nx_secure_dtls_psk_add.c nx_secure_dtls_receive_callback.c nx_secure_dtls_retransmit.c nx_secure_dtls_retransmit_queue_flush.c nx_secure_dtls_send_clienthello.c nx_secure_dtls_send_handshake_record.c nx_secure_dtls_send_helloverifyrequest.c nx_secure_dtls_send_record.c nx_secure_dtls_send_serverhello.c nx_secure_dtls_server_create.c nx_secure_dtls_server_delete.c nx_secure_dtls_server_ecc_initialize.c nx_secure_dtls_server_handshake.c nx_secure_dtls_server_local_certificate_add.c nx_secure_dtls_server_local_certificate_remove.c nx_secure_dtls_server_notify_set.c nx_secure_dtls_server_protocol_version_override.c nx_secure_dtls_server_psk_add.c nx_secure_dtls_server_session_send.c nx_secure_dtls_server_session_start.c nx_secure_dtls_server_start.c nx_secure_dtls_server_stop.c nx_secure_dtls_server_trusted_certificate_add.c nx_secure_dtls_server_trusted_certificate_remove.c nx_secure_dtls_server_x509_client_verify_configure.c nx_secure_dtls_server_x509_client_verify_disable.c nx_secure_dtls_session_cache.c nx_secure_dtls_session_client_info_get.c nx_secure_dtls_session_create.c nx_secure_dtls_session_delete.c nx_secure_dtls_session_end.c nx_secure_dtls_session_local_certificate_add.c nx_secure_dtls_session_local_certificate_remove.c nx_secure_dtls_session_receive.c nx_secure_dtls_session_reset.c nx_secure_dtls_session_send.c nx_secure_dtls_session_start.c nx_secure_dtls_session_trusted_certificate_add.c nx_secure_dtls_session_trusted_certificate_remove.c nx_secure_dtls_verify_mac.c nx_secure_generate_client_key_exchange.c nx_secure_generate_master_secret.c nx_secure_generate_premaster_secret.c nx_secure_generate_server_key_exchange.c nx_secure_generate_session_keys.c nx_secure_module_hash_compute.c nx_secure_process_client_key_exchange.c nx_secure_process_server_key_exchange.c nx_secure_remote_certificate_verify.c nx_secure_session_keys_set.c nx_secure_tls_1_3_client_handshake.c nx_secure_tls_1_3_crypto_init.c nx_secure_tls_1_3_finished_hash_generate.c nx_secure_tls_1_3_generate_keys.c nx_secure_tls_1_3_server_handshake.c nx_secure_tls_1_3_session_keys_set.c nx_secure_tls_1_3_transcript_hash_save.c nx_secure_tls_active_certificate_set.c nx_secure_tls_allocate_handshake_packet.c nx_secure_tls_check_protocol_version.c nx_secure_tls_ciphersuite_lookup.c nx_secure_tls_client_handshake.c nx_secure_tls_client_psk_set.c nx_secure_tls_ecc_generate_keys.c nx_secure_tls_ecc_initialize.c nx_secure_tls_find_curve_method.c nx_secure_tls_finished_hash_generate.c nx_secure_tls_generate_keys.c nx_secure_tls_generate_premaster_secret.c nx_secure_tls_handshake_hash_init.c nx_secure_tls_handshake_hash_update.c nx_secure_tls_handshake_process.c nx_secure_tls_hash_record.c nx_secure_tls_initialize.c nx_secure_tls_key_material_init.c nx_secure_tls_local_certificate_add.c nx_secure_tls_local_certificate_find.c nx_secure_tls_local_certificate_remove.c nx_secure_tls_map_error_to_alert.c nx_secure_tls_metadata_size_calculate.c nx_secure_tls_newest_supported_version.c nx_secure_tls_packet_allocate.c nx_secure_tls_packet_release.c nx_secure_tls_process_certificate_request.c nx_secure_tls_process_certificate_verify.c nx_secure_tls_process_changecipherspec.c nx_secure_tls_process_client_key_exchange.c nx_secure_tls_process_clienthello.c nx_secure_tls_process_clienthello_extensions.c nx_secure_tls_process_encrypted_extensions.c nx_secure_tls_process_finished.c nx_secure_tls_process_handshake_header.c nx_secure_tls_process_header.c nx_secure_tls_process_newsessionticket.c nx_secure_tls_process_record.c nx_secure_tls_process_remote_certificate.c nx_secure_tls_process_server_key_exchange.c nx_secure_tls_process_serverhello.c nx_secure_tls_process_serverhello_extensions.c nx_secure_tls_protocol_version_get.c nx_secure_tls_psk_add.c nx_secure_tls_psk_binder_generate.c nx_secure_tls_psk_find.c nx_secure_tls_psk_identity_find.c nx_secure_tls_record_hash_calculate.c nx_secure_tls_record_hash_initialize.c nx_secure_tls_record_hash_update.c nx_secure_tls_record_payload_decrypt.c nx_secure_tls_record_payload_encrypt.c nx_secure_tls_remote_certificate_allocate.c nx_secure_tls_remote_certificate_buffer_allocate.c nx_secure_tls_remote_certificate_free.c nx_secure_tls_remote_certificate_free_all.c nx_secure_tls_remote_certificate_verify.c nx_secure_tls_send_alert.c nx_secure_tls_send_certificate.c nx_secure_tls_send_certificate_request.c nx_secure_tls_send_certificate_verify.c nx_secure_tls_send_changecipherspec.c nx_secure_tls_send_client_key_exchange.c nx_secure_tls_send_clienthello.c nx_secure_tls_send_clienthello_extensions.c nx_secure_tls_send_encrypted_extensions.c nx_secure_tls_send_finished.c nx_secure_tls_send_handshake_record.c nx_secure_tls_send_hellorequest.c nx_secure_tls_send_newsessionticket.c nx_secure_tls_send_record.c nx_secure_tls_send_server_key_exchange.c nx_secure_tls_send_serverhello.c nx_secure_tls_send_serverhello_extensions.c nx_secure_tls_server_certificate_add.c nx_secure_tls_server_certificate_find.c nx_secure_tls_server_certificate_remove.c nx_secure_tls_server_handshake.c nx_secure_tls_session_alert_value_get.c nx_secure_tls_session_certificate_callback_set.c nx_secure_tls_session_client_callback_set.c nx_secure_tls_session_client_verify_disable.c nx_secure_tls_session_client_verify_enable.c nx_secure_tls_session_create.c nx_secure_tls_session_create_ext.c nx_secure_tls_session_delete.c nx_secure_tls_session_end.c nx_secure_tls_session_iv_size_get.c nx_secure_tls_session_keys_set.c nx_secure_tls_session_packet_buffer_set.c nx_secure_tls_session_packet_pool_set.c nx_secure_tls_session_protocol_version_override.c nx_secure_tls_session_receive.c nx_secure_tls_session_receive_records.c nx_secure_tls_session_renegotiate.c nx_secure_tls_session_renegotiate_callback_set.c nx_secure_tls_session_reset.c nx_secure_tls_session_send.c nx_secure_tls_session_server_callback_set.c nx_secure_tls_session_sni_extension_parse.c nx_secure_tls_session_sni_extension_set.c nx_secure_tls_session_start.c nx_secure_tls_session_time_function_set.c nx_secure_tls_session_x509_client_verify_configure.c nx_secure_tls_shutdown.c nx_secure_tls_trusted_certificate_add.c nx_secure_tls_trusted_certificate_remove.c nx_secure_tls_verify_mac.c nx_secure_trusted_certificate_add.c nx_secure_verify_mac.c nx_secure_x509.c nx_secure_x509_asn1_tlv_block_parse.c nx_secure_x509_certificate_chain_verify.c nx_secure_x509_certificate_initialize.c nx_secure_x509_certificate_list_add.c nx_secure_x509_certificate_list_find.c nx_secure_x509_certificate_list_remove.c nx_secure_x509_certificate_revocation_list_parse.c nx_secure_x509_certificate_verify.c nx_secure_x509_common_name_dns_check.c nx_secure_x509_crl_revocation_check.c nx_secure_x509_crl_verify.c nx_secure_x509_distinguished_name_compare.c nx_secure_x509_distinguished_name_parse.c nx_secure_x509_dns_name_initialize.c nx_secure_x509_ec_private_key_parse.c nx_secure_x509_expiration_check.c nx_secure_x509_extended_key_usage_extension_parse.c nx_secure_x509_extension_find.c nx_secure_x509_find_certificate_methods.c nx_secure_x509_find_curve_method.c nx_secure_x509_free_certificate_get.c nx_secure_x509_key_usage_extension_parse.c nx_secure_x509_local_certificate_find.c nx_secure_x509_local_device_certificate_get.c nx_secure_x509_oid_parse.c nx_secure_x509_pkcs1_rsa_private_key_parse.c nx_secure_x509_pkcs7_decode.c nx_secure_x509_remote_endpoint_certificate_get.c nx_secure_x509_store_certificate_add.c nx_secure_x509_store_certificate_find.c nx_secure_x509_store_certificate_remove.c nx_secure_x509_subject_alt_names_find.c nx_secure_x509_wildcard_compare.c nxe_secure_dtls_client_protocol_version_override.c nxe_secure_dtls_client_session_start.c nxe_secure_dtls_ecc_initialize.c nxe_secure_dtls_packet_allocate.c nxe_secure_dtls_psk_add.c nxe_secure_dtls_server_create.c nxe_secure_dtls_server_delete.c nxe_secure_dtls_server_ecc_initialize.c nxe_secure_dtls_server_local_certificate_add.c nxe_secure_dtls_server_local_certificate_remove.c nxe_secure_dtls_server_notify_set.c nxe_secure_dtls_server_protocol_version_override.c nxe_secure_dtls_server_psk_add.c nxe_secure_dtls_server_session_send.c nxe_secure_dtls_server_session_start.c nxe_secure_dtls_server_start.c nxe_secure_dtls_server_stop.c nxe_secure_dtls_server_trusted_certificate_add.c nxe_secure_dtls_server_trusted_certificate_remove.c nxe_secure_dtls_server_x509_client_verify_configure.c nxe_secure_dtls_server_x509_client_verify_disable.c nxe_secure_dtls_session_client_info_get.c nxe_secure_dtls_session_create.c nxe_secure_dtls_session_delete.c nxe_secure_dtls_session_end.c nxe_secure_dtls_session_local_certificate_add.c nxe_secure_dtls_session_local_certificate_remove.c nxe_secure_dtls_session_receive.c nxe_secure_dtls_session_reset.c nxe_secure_dtls_session_send.c nxe_secure_dtls_session_start.c nxe_secure_dtls_session_trusted_certificate_add.c nxe_secure_dtls_session_trusted_certificate_remove.c nxe_secure_tls_active_certificate_set.c nxe_secure_tls_client_psk_set.c nxe_secure_tls_local_certificate_add.c nxe_secure_tls_local_certificate_find.c nxe_secure_tls_local_certificate_remove.c nxe_secure_tls_metadata_size_calculate.c nxe_secure_tls_packet_allocate.c nxe_secure_tls_psk_add.c nxe_secure_tls_remote_certificate_allocate.c nxe_secure_tls_remote_certificate_buffer_allocate.c nxe_secure_tls_remote_certificate_free_all.c nxe_secure_tls_server_certificate_add.c nxe_secure_tls_server_certificate_find.c nxe_secure_tls_server_certificate_remove.c nxe_secure_tls_session_alert_value_get.c nxe_secure_tls_session_certificate_callback_set.c nxe_secure_tls_session_client_callback_set.c nxe_secure_tls_session_client_verify_disable.c nxe_secure_tls_session_client_verify_enable.c nxe_secure_tls_session_create.c nxe_secure_tls_session_delete.c nxe_secure_tls_session_end.c nxe_secure_tls_session_packet_buffer_set.c nxe_secure_tls_session_packet_pool_set.c nxe_secure_tls_session_protocol_version_override.c nxe_secure_tls_session_receive.c nxe_secure_tls_session_renegotiate.c nxe_secure_tls_session_renegotiate_callback_set.c nxe_secure_tls_session_reset.c nxe_secure_tls_session_send.c nxe_secure_tls_session_server_callback_set.c nxe_secure_tls_session_sni_extension_parse.c nxe_secure_tls_session_sni_extension_set.c nxe_secure_tls_session_start.c nxe_secure_tls_session_time_function_set.c nxe_secure_tls_session_x509_client_verify_configure.c nxe_secure_tls_trusted_certificate_add.c nxe_secure_tls_trusted_certificate_remove.c nxe_secure_x509_certificate_initialize.c nxe_secure_x509_common_name_dns_check.c nxe_secure_x509_crl_revocation_check.c nxe_secure_x509_dns_name_initialize.c nxe_secure_x509_extended_key_usage_extension_parse.c nxe_secure_x509_extension_find.c nxe_secure_x509_key_usage_extension_parse.c
  group Middlewares/threadx/core
    ../../../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Middlewares/threadx/ports
    ../../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_iar.c tx_initialize_low_level.s tx_misra.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack.c tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_secure_stack_initialize.s tx_thread_stack_build.s tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_return.s tx_timer_interrupt.s txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c
  group Middlewares/trustedfirmware/core
    ../../NonSecure/Core/Src/: tfm_app_rot_ipc_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_firmware_update_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_ps_ipc_api.c tfm_psa_ns_api.c
    ../../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
